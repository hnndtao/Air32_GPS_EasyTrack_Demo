# Keil uVision project Base.uvprojx, settings and files
target Base (5060960::V5.06 update 7 (build 960)::.\Com 5.06)
  device: AIR32F103CB Generic
  pack: Keil.AIR32F103_DFP.1.1.6
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Base +hex
  c flags: Optim=2 uC99=1 v6Lang=1 v6LangP=5
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Firmware\AIR32F10xLib\inc;..\Firmware\AIR32F10xLib\lib\cryptlib;..\Firmware\CMSIS\Include;..\Bsp;..\App;..\user;..\Fusion;..\Common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group App
    ../App/: lcd_init.c lcd.c icm42688.c gps_air530z.c path_tracking.c
  group Common
    ../Common/: fifo.c function.c control.c
  group Fusion
    ../Fusion/: FusionAhrs.c FusionCompass.c FusionOffset.c
  group BSP
    ../Bsp/: bsp_base.c can.c flash_manage.c
  group Doc
    ../Doc/: readme.txt
  group Firmware
    ../Firmware/AIR32F10xLib/src/: air32f10x_adc.c air32f10x_crc.c air32f10x_dbgmcu.c air32f10x_dma.c air32f10x_exti.c air32f10x_flash.c air32f10x_gpio.c air32f10x_i2c.c air32f10x_rcc.c air32f10x_rcc_ex.c air32f10x_rtc.c air32f10x_spi.c air32f10x_tim.c air32f10x_usart.c misc.c air32f10x_can.c
  group User
    ../user/: air32f10x_it.c delay.c main.c
  group CMSIS
    ../Firmware/STARTUP/arm/: startup_air32f10x.s
    ../Firmware/AIR32F10xLib/src/: system_air32f10x.c
software components: CMSIS:CORE 5.6.0
